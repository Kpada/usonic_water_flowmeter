# Keil uVision project waterSpeed.uvprojx, settings and files
target hw-2.0-demoBoard (ARM-ADS)
  device: STM32L100RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x2800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: waterSpeed +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\src;.\src\STM32L1xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group config
    ./src/config/: dataProcessorConfig.h ringbuffConfig.h tdc-gp22Config.h
  group header
    ./src/: stdAfx.h typedef.h data.h
  group startup
    ./src/startup/: startup_stm32l1xx_md.s system_stm32l1xx.c
  group application
    ./src/: uart.c delay.c ringbuff.c main.c spi.c tdc-gp22.c dataProcessor.c
  group board drivers
    ./src/demoBoard/: boardLeds.c boardLcd.c boardButtons.c
  group rpc
    ./src/: protocol.c rpc.c rpcHandlers.c crc.c rpcMap.cc
  group lib
    ./src/STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_lcd.c stm32l1xx_rcc.c stm32l1xx_spi.c stm32l1xx_gpio.c stm32l1xx_usart.c stm32l1xx_pwr.c
software components: CMSIS:CORE 4.1.0
