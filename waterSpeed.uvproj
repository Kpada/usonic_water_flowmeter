# Keil uVision project waterSpeed.uvproj, settings and files
target hw-1.0-demoBoard (ARM-ADS)
  device: STM32L100RB STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: waterSpeed
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\src;..\..\..\ekosf\common;.\src\STM32L1xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group startup
    ./src/startup/: startup_stm32l1xx_md.s system_stm32l1xx.c
  group application
    ./src/: main.c spi.c uart.c protocol.c protocolHandlers.c
    ../../../ekosf/common/: ringbuff.c
  group board drivers
    ./src/demoBoard/: boardLeds.c boardButtons.c boardLcd.c
    ./src/: tdc-gp22.c
  group header
    ./src/: stdAfx.h
    ../../../ekosf/common/: typedef.h
  group common
    ../../../ekosf/common/: delay.c
  group lib
    ./src/STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_lcd.c stm32l1xx_rcc.c stm32l1xx_spi.c stm32l1xx_gpio.c stm32l1xx_usart.c
